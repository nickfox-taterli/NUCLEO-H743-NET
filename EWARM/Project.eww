<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NUCLEO-H743ZI.ewp</path>
  </project>
  <batchBuild />
</workspace>
